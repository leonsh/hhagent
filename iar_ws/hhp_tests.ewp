# IAR project hhp_tests.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: UNITY_NO_WEAK; UNITY_OUTPUT_FLUSH; UNITY_OMIT_OUTPUT_FLUSH_HEADER_DECLARATION
  ICCARM.CCIncludePath2: ..\include; ..\Unity\src; ..\src; ..\src\emsnmp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: hhp_tests.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group include
    ../include/: compiler.h hhp.h hhp_config.h hhp_error_code.h hhp_oid.h
  group src
    ../src/: crc16.c crc16.h hhp_core.c hhp_core.h hhp_msg_entry.c
    ../: main.c
  group src/emsnmp
    ../src/emsnmp/: emsnmp.c emsnmp.h
  group tests
    ../tests/: main.c test_hhp_core.c unity_config.h
  group Unity
    ../Unity/src/: unity.c unity.h unity_internals.h
